v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -940 -260 -890 -260 { lab=q4}
N -940 -220 -890 -220 { lab=q4b}
N -630 -270 -580 -270 { lab=q3}
N -630 -230 -580 -230 { lab=q3b}
N -330 -270 -280 -270 { lab=q2}
N -330 -230 -280 -230 { lab=q2b}
N -20 -280 30 -280 { lab=q1}
N -20 -240 40 -240 { lab=q1b}
N 300 -290 360 -290 { lab=q0}
N 300 -250 360 -250 { lab=q0b}
N -1140 -230 -1060 -230 { lab=c_clk}
N -1140 -190 -1060 -190 { lab=reset}
N -810 -240 -750 -240 { lab=c_clk}
N -810 -200 -750 -200 { lab=reset}
N -510 -240 -450 -240 { lab=c_clk}
N -510 -200 -450 -200 { lab=reset}
N -200 -250 -140 -250 { lab=c_clk}
N -200 -210 -140 -210 { lab=reset}
N 100 -260 180 -260 { lab=c_clk}
N -1560 -520 -1520 -520 { lab=q3}
N -1560 -500 -1520 -500 { lab=q2}
N -1560 -480 -1520 -480 { lab=q1}
N -1560 -460 -1520 -460 { lab=q0}
N -1470 -500 -1440 -500 { lab=#net1}
N -1440 -550 -1300 -550 { lab=#net1}
N -1440 -550 -1440 -500 { lab=#net1}
N -1440 -500 -1420 -500 { lab=#net1}
N -1380 -500 -1300 -500 { lab=#net2}
N -1350 -450 -1300 -450 { lab=q4}
N -1350 -400 -1300 -400 { lab=q4b}
N -1140 -470 -1120 -470 { lab=c4}
N -1120 -280 -1060 -280 { lab=d4}
N -1150 -660 -1120 -660 { lab=q2}
N -1150 -640 -1120 -640 { lab=q1}
N -1150 -620 -1120 -620 { lab=q0}
N -1070 -640 -1040 -640 { lab=#net3}
N -1040 -660 -1040 -640 { lab=#net3}
N -1040 -660 -960 -660 { lab=#net3}
N -1040 -640 -1040 -610 { lab=#net3}
N -1040 -610 -1030 -610 { lab=#net3}
N -990 -610 -960 -610 { lab=#net4}
N -1020 -560 -960 -560 { lab=q3}
N -1020 -510 -960 -510 { lab=q3b}
N -800 -580 -790 -580 { lab=c3}
N -790 -290 -750 -290 { lab=d3}
N -780 -620 -750 -620 { lab=q1}
N -780 -580 -750 -580 { lab=q0}
N -700 -600 -690 -600 { lab=#net5}
N -690 -630 -690 -600 { lab=#net5}
N -690 -630 -650 -630 { lab=#net5}
N -690 -600 -690 -580 { lab=#net5}
N -690 -530 -650 -530 { lab=q2}
N -690 -480 -650 -480 { lab=q2b}
N -490 -550 -480 -550 { lab=c2}
N -480 -290 -450 -290 { lab=d2}
N -410 -640 -340 -640 { lab=q0}
N -410 -590 -340 -590 { lab=q0b}
N -410 -540 -340 -540 { lab=q1}
N -410 -490 -340 -490 { lab=q1b}
N -180 -300 -140 -300 { lab=d1}
N 110 -310 180 -310 { lab=d0}
N -1160 -230 -1140 -230 { lab=c_clk}
N -1160 -230 -1160 -30 { lab=c_clk}
N -1160 -30 100 -30 { lab=c_clk}
N 100 -260 100 -30 { lab=c_clk}
N -840 -240 -810 -240 { lab=c_clk}
N -840 -240 -840 -30 { lab=c_clk}
N -550 -240 -510 -240 { lab=c_clk}
N -550 -240 -550 -30 { lab=c_clk}
N -230 -250 -200 -250 { lab=c_clk}
N -230 -250 -230 -30 { lab=c_clk}
N -1140 -190 -1140 -120 { lab=reset}
N -1140 -120 -820 -120 { lab=reset}
N -820 -200 -820 -120 { lab=reset}
N -820 -200 -810 -200 { lab=reset}
N -820 -120 -510 -120 { lab=reset}
N -510 -200 -510 -120 { lab=reset}
N -510 -120 -200 -120 { lab=reset}
N -200 -210 -200 -120 { lab=reset}
N -200 -120 140 -120 { lab=reset}
N 140 -220 140 -120 { lab=reset}
N 140 -220 180 -220 { lab=reset}
N -540 110 -500 110 { lab=q0}
N -540 130 -500 130 { lab=q1}
N -540 150 -500 150 { lab=q2}
N -540 170 -500 170 { lab=q3}
N -540 190 -500 190 { lab=q4}
N -450 130 -420 130 { lab=flag}
N -1120 -470 -1120 -380 { lab=c4}
N -1120 -320 -1120 -280 { lab=d4}
N -790 -580 -790 -420 { lab=c3}
N -790 -360 -790 -290 { lab=d3}
N -480 -350 -480 -290 { lab=d2}
N -480 -550 -480 -410 { lab=c2}
N -180 -560 -180 -430 { lab=c1}
N -180 -370 -180 -300 { lab=d1}
N 110 -410 110 -310 { lab=d0}
N -380 130 -340 130 { lab=flagb}
N -480 -360 -480 -350 { lab=d2}
N -2120 -500 -2050 -460 { lab=#net6}
N -2120 -420 -2050 -420 { lab=#net7}
N -2000 -440 -1950 -440 { lab=d4}
N -2210 -480 -2170 -480 { lab=c4}
N -2220 -520 -2170 -520 { lab=flagb}
N -2210 -440 -2170 -440 { lab=a4}
N -2210 -400 -2170 -400 { lab=flag}
N -2130 -270 -2060 -230 { lab=#net8}
N -2130 -190 -2060 -190 { lab=#net9}
N -2010 -210 -1960 -210 { lab=d3}
N -2220 -250 -2180 -250 { lab=c3}
N -2230 -290 -2180 -290 { lab=flagb}
N -2220 -210 -2180 -210 { lab=a3}
N -2220 -170 -2180 -170 { lab=flag}
N -2140 -40 -2070 0 { lab=#net10}
N -2140 40 -2070 40 { lab=#net11}
N -2020 20 -1970 20 { lab=d2}
N -2230 -20 -2190 -20 { lab=c2}
N -2240 -60 -2190 -60 { lab=flagb}
N -2230 20 -2190 20 { lab=a2}
N -2230 60 -2190 60 { lab=flag}
N -2140 180 -2070 220 { lab=#net12}
N -2140 260 -2070 260 { lab=#net13}
N -2020 240 -1970 240 { lab=d1}
N -2230 200 -2190 200 { lab=c1}
N -2240 160 -2190 160 { lab=flagb}
N -2230 240 -2190 240 { lab=a1}
N -2230 280 -2190 280 { lab=flag}
N -2140 400 -2070 440 { lab=#net14}
N -2140 480 -2070 480 { lab=#net15}
N -2020 460 -1970 460 { lab=d0}
N -2230 420 -2190 420 { lab=q0b}
N -2240 380 -2190 380 { lab=flagb}
N -2230 460 -2190 460 { lab=a0}
N -2230 500 -2190 500 { lab=flag}
C {/home/vinodhini/Documents/dff1.sym} -1080 -150 0 0 {name=X1}
C {/home/vinodhini/Documents/dff1.sym} -770 -160 0 0 {name=X2}
C {/home/vinodhini/Documents/dff1.sym} -470 -160 0 0 {name=X3}
C {/home/vinodhini/Documents/dff1.sym} -160 -170 0 0 {name=X4}
C {/home/vinodhini/Documents/dff1.sym} 160 -180 0 0 {name=X5}
C {devices/lab_pin.sym} 320 -290 1 0 {name=l1 sig_type=std_logic lab=q0}
C {devices/lab_pin.sym} 320 -250 1 0 {name=l2 sig_type=std_logic lab=q0b}
C {devices/lab_pin.sym} -10 -280 1 0 {name=l3 sig_type=std_logic lab=q1}
C {devices/lab_pin.sym} 10 -240 1 0 {name=l4 sig_type=std_logic lab=q1b}
C {devices/lab_pin.sym} -320 -270 1 0 {name=l5 sig_type=std_logic lab=q2}
C {devices/lab_pin.sym} -320 -230 1 0 {name=l6 sig_type=std_logic lab=q2b}
C {devices/lab_pin.sym} -610 -270 1 0 {name=l7 sig_type=std_logic lab=q3}
C {devices/lab_pin.sym} -620 -230 1 0 {name=l8 sig_type=std_logic lab=q3b}
C {devices/lab_pin.sym} -930 -260 1 0 {name=l9 sig_type=std_logic lab=q4}
C {devices/lab_pin.sym} -920 -220 1 0 {name=l10 sig_type=std_logic lab=q4b}
C {/home/vinodhini/Documents/four_input_and.symbol} -780 -250 0 0 {name=X6}
C {devices/lab_pin.sym} -1540 -520 1 0 {name=l11 sig_type=std_logic lab=q3}
C {devices/lab_pin.sym} -1550 -500 1 0 {name=l12 sig_type=std_logic lab=q2}
C {devices/lab_pin.sym} -1530 -480 1 0 {name=l13 sig_type=std_logic lab=q1}
C {devices/lab_pin.sym} -1540 -460 1 0 {name=l14 sig_type=std_logic lab=q0}
C {/home/vinodhini/Documents/two_input_exor.sym} -1180 -430 0 0 {name=X7}
C {/home/vinodhini/Documents/inverter.sym} -320 -280 0 0 {name=X8}
C {devices/lab_pin.sym} -1330 -450 1 0 {name=l15 sig_type=std_logic lab=q4}
C {devices/lab_pin.sym} -1320 -400 1 0 {name=l16 sig_type=std_logic lab=q4b}
C {/home/vinodhini/Documents/two_input_exor.sym} -840 -540 0 0 {name=X9}
C {/home/vinodhini/Documents/three_input_and.symbol} -380 -390 0 0 {name=X10}
C {devices/lab_pin.sym} -1140 -660 1 0 {name=l17 sig_type=std_logic lab=q2}
C {devices/lab_pin.sym} -1150 -640 1 0 {name=l18 sig_type=std_logic lab=q1}
C {devices/lab_pin.sym} -1150 -620 0 0 {name=l19 sig_type=std_logic lab=q0}
C {/home/vinodhini/Documents/inverter.sym} 70 -390 0 0 {name=X11}
C {devices/lab_pin.sym} -980 -560 1 0 {name=l20 sig_type=std_logic lab=q3}
C {devices/lab_pin.sym} -990 -510 1 0 {name=l21 sig_type=std_logic lab=q3b}
C {/home/vinodhini/Documents/two_input_and.symbol} -10 -350 0 0 {name=X12}
C {/home/vinodhini/Documents/two_input_exor.sym} -530 -510 0 0 {name=X13}
C {devices/lab_pin.sym} -760 -620 1 0 {name=l22 sig_type=std_logic lab=q1}
C {devices/lab_pin.sym} -770 -580 1 0 {name=l23 sig_type=std_logic lab=q0}
C {/home/vinodhini/Documents/inverter.sym} 410 -360 0 0 {name=X14}
C {devices/lab_pin.sym} -690 -530 0 0 {name=l24 sig_type=std_logic lab=q2}
C {devices/lab_pin.sym} -690 -480 0 0 {name=l25 sig_type=std_logic lab=q2b}
C {/home/vinodhini/Documents/two_input_exor.sym} -220 -520 0 0 {name=X15}
C {devices/lab_pin.sym} -370 -640 1 0 {name=l28 sig_type=std_logic lab=q0}
C {devices/lab_pin.sym} -360 -590 1 0 {name=l29 sig_type=std_logic lab=q0b}
C {devices/lab_pin.sym} -380 -540 1 0 {name=l30 sig_type=std_logic lab=q1}
C {devices/lab_pin.sym} -370 -490 1 0 {name=l31 sig_type=std_logic lab=q1b}
C {devices/lab_pin.sym} -620 -30 1 0 {name=l32 sig_type=std_logic lab=c_clk}
C {devices/lab_pin.sym} -350 -120 1 0 {name=l33 sig_type=std_logic lab=reset}
C {/home/vinodhini/Documents/five_input_and.symbol} 240 380 0 0 {name=X16}
C {devices/lab_pin.sym} -510 110 1 0 {name=l34 sig_type=std_logic lab=q0}
C {devices/lab_pin.sym} -520 130 1 0 {name=l35 sig_type=std_logic lab=q1}
C {devices/lab_pin.sym} -530 150 1 0 {name=l36 sig_type=std_logic lab=q2}
C {devices/lab_pin.sym} -510 170 1 0 {name=l39 sig_type=std_logic lab=q3}
C {devices/lab_pin.sym} -520 190 1 0 {name=l40 sig_type=std_logic lab=q4}
C {devices/lab_pin.sym} -440 130 1 0 {name=l41 sig_type=std_logic lab=flag}
C {devices/lab_pin.sym} -160 -300 1 0 {name=l49 sig_type=std_logic lab=d1}
C {devices/lab_pin.sym} -460 -290 1 0 {name=l50 sig_type=std_logic lab=d2}
C {devices/lab_pin.sym} -770 -290 1 0 {name=l51 sig_type=std_logic lab=d3}
C {devices/lab_pin.sym} -1090 -280 1 0 {name=l52 sig_type=std_logic lab=d4}
C {/home/vinodhini/Documents/inverter.sym} 680 350 0 0 {name=X17}
C {devices/lab_pin.sym} -360 130 1 0 {name=l42 sig_type=std_logic lab=flagb}
C {devices/lab_pin.sym} 140 -310 1 0 {name=l66 sig_type=std_logic lab=d0}
C {devices/lab_pin.sym} -1120 -410 2 0 {name=l43 sig_type=std_logic lab=c4}
C {devices/lab_pin.sym} -790 -450 2 0 {name=l44 sig_type=std_logic lab=c3}
C {devices/lab_pin.sym} -480 -460 2 0 {name=l45 sig_type=std_logic lab=c2}
C {devices/lab_pin.sym} -180 -460 2 0 {name=l46 sig_type=std_logic lab=c1}
C {/home/vinodhini/Documents/two_input_and.symbol} -1430 -250 0 0 {name=X18}
C {/home/vinodhini/Documents/two_input_or.symbol} -1310 -190 0 0 {name=X19}
C {/home/vinodhini/Documents/two_input_and.symbol} -1430 -170 0 0 {name=X20}
C {devices/lab_pin.sym} -1970 -440 1 0 {name=l47 sig_type=std_logic lab=d4}
C {devices/lab_pin.sym} -2190 -520 1 0 {name=l48 sig_type=std_logic lab=flagb}
C {devices/lab_pin.sym} -2190 -400 3 0 {name=l53 sig_type=std_logic lab=flag}
C {devices/lab_pin.sym} -2210 -480 0 0 {name=l54 sig_type=std_logic lab=c4}
C {devices/lab_pin.sym} -2190 -440 1 0 {name=l55 sig_type=std_logic lab=a4}
C {/home/vinodhini/Documents/two_input_and.symbol} -1440 -20 0 0 {name=X21}
C {/home/vinodhini/Documents/two_input_or.symbol} -1320 40 0 0 {name=X22}
C {/home/vinodhini/Documents/two_input_and.symbol} -1440 60 0 0 {name=X23}
C {devices/lab_pin.sym} -1980 -210 1 0 {name=l56 sig_type=std_logic lab=d3}
C {devices/lab_pin.sym} -2200 -290 1 0 {name=l57 sig_type=std_logic lab=flagb}
C {devices/lab_pin.sym} -2200 -170 3 0 {name=l58 sig_type=std_logic lab=flag}
C {devices/lab_pin.sym} -2220 -250 0 0 {name=l59 sig_type=std_logic lab=c3}
C {devices/lab_pin.sym} -2190 -210 1 0 {name=l60 sig_type=std_logic lab=a3}
C {/home/vinodhini/Documents/two_input_and.symbol} -1450 210 0 0 {name=X24}
C {/home/vinodhini/Documents/two_input_or.symbol} -1330 270 0 0 {name=X25}
C {/home/vinodhini/Documents/two_input_and.symbol} -1450 290 0 0 {name=X26}
C {devices/lab_pin.sym} -1990 20 1 0 {name=l61 sig_type=std_logic lab=d2}
C {devices/lab_pin.sym} -2210 -60 1 0 {name=l62 sig_type=std_logic lab=flagb}
C {devices/lab_pin.sym} -2210 60 3 0 {name=l63 sig_type=std_logic lab=flag}
C {devices/lab_pin.sym} -2230 -20 0 0 {name=l64 sig_type=std_logic lab=c2}
C {devices/lab_pin.sym} -2210 20 1 0 {name=l65 sig_type=std_logic lab=a2}
C {/home/vinodhini/Documents/two_input_and.symbol} -1450 430 0 0 {name=X27}
C {/home/vinodhini/Documents/two_input_or.symbol} -1330 490 0 0 {name=X28}
C {/home/vinodhini/Documents/two_input_and.symbol} -1450 510 0 0 {name=X29}
C {devices/lab_pin.sym} -1990 240 1 0 {name=l67 sig_type=std_logic lab=d1}
C {devices/lab_pin.sym} -2210 160 1 0 {name=l78 sig_type=std_logic lab=flagb}
C {devices/lab_pin.sym} -2210 280 3 0 {name=l79 sig_type=std_logic lab=flag}
C {devices/lab_pin.sym} -2230 200 0 0 {name=l80 sig_type=std_logic lab=c1}
C {devices/lab_pin.sym} -2210 240 1 0 {name=l81 sig_type=std_logic lab=a1}
C {/home/vinodhini/Documents/two_input_and.symbol} -1450 650 0 0 {name=X30}
C {/home/vinodhini/Documents/two_input_or.symbol} -1330 710 0 0 {name=X31}
C {/home/vinodhini/Documents/two_input_and.symbol} -1450 730 0 0 {name=X32}
C {devices/lab_pin.sym} -1990 460 1 0 {name=l82 sig_type=std_logic lab=d0}
C {devices/lab_pin.sym} -2210 380 1 0 {name=l83 sig_type=std_logic lab=flagb}
C {devices/lab_pin.sym} -2210 500 3 0 {name=l84 sig_type=std_logic lab=flag}
C {devices/lab_pin.sym} -2230 420 0 0 {name=l85 sig_type=std_logic lab=q0b}
C {devices/lab_pin.sym} -2210 460 1 0 {name=l86 sig_type=std_logic lab=a0}
C {devices/ipin.sym} -2200 -440 0 0 {name=p1 lab=a4}
C {devices/ipin.sym} -2210 -210 0 0 {name=p2 lab=a3}
C {devices/ipin.sym} -2220 20 0 0 {name=p3 lab=a2}
C {devices/ipin.sym} -2220 240 0 0 {name=p4 lab=a1}
C {devices/ipin.sym} -2220 460 0 0 {name=p5 lab=a0}
C {devices/opin.sym} -900 -260 0 0 {name=p6 lab=q4}
C {devices/opin.sym} -590 -270 0 0 {name=p7 lab=q3}
C {devices/opin.sym} -290 -270 0 0 {name=p8 lab=q2}
C {devices/opin.sym} 20 -280 0 0 {name=p9 lab=q1}
C {devices/opin.sym} 350 -290 0 0 {name=p10 lab=q0}
C {devices/ipin.sym} -380 -130 3 0 {name=p11 lab=reset}
C {devices/ipin.sym} -690 -40 3 0 {name=p12 lab=c_clk}
C {devices/opin.sym} -2200 -400 2 0 {name=p13 lab=flag}
